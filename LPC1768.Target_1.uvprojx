# Keil uVision project LPC1768.Target_1.uvprojx, settings and files
target Target_1 (6180000::V6.18::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LPC1768
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c misc: -Wno-documentation -Wno-documentation-unknown-command -Wno-license-management -Wno-missing-noreturn -Wno-missing-prototypes -Wno-missing-variable-declarations -Wno-nonportable-include-path -Wno-packed -Wno-parentheses-equality -Wno-reserved-id-macro -Wno-unused-macros -xc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ./LPC1768.Target 1.sct
  link misc: --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
  group Source Group 1
    ./: LED_1768.c Board_LED.h Blinky.c main.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
